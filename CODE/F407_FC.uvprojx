# Keil uVision project F407_FC.uvprojx, settings and files
target Anopilot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\Libraries\TZ
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./applications/: include.h stm32f4xx_conf.h main.c stm32f4xx_it.c scheduler.c scheduler.h init.c init.h parameter.c parameter.h ctrl.c ctrl.h imu.c imu.h mymath.c mymath.h data_transfer.c data_transfer.h rc.c rc.h usb_config.c usbd_user_hid.c version.c filter.c filter.h height_ctrl.c height_ctrl.h fly_mode.c fly_mode.h anotc_baro_ctrl.c anotc_baro_ctrl.h PID.c PID.h
  group Drivers
    ./drivers/: time.c time.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h i2c_soft.c i2c_soft.h mpu6050.c mpu6050.h ak8975.c ak8975.h led.c led.h ms5611.c ms5611.h usart.c usart.h usbd_STM32F4xx_FS.c drv_w25qxx.c ultrasonic.c ultrasonic.h oled.c pmu_adc.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USBStack
    ./Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group FatFs
    ./Libraries/FatFS/src/: diskio.c ff.c
  group Note
    ./doc/: note.txt record.txt
  group TZ
    ./Libraries/TZ/: TZ_PID.c TZ_PID.h setheight.c setheight.h auto_takeoff.c auto_takeoff.h TZ_PosHold.c TZ_PosHold.h TZ_DirectionHold.c TZ_DirectionHold.h
